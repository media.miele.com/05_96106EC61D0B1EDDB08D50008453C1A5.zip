Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-03-07T11:32:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 07 11:32:48 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\3019eec8-1e46-473c-9b16-792acbb5a9a7\a92e66e6-4d9b-4245-934c-2a28bc8a219c\ifc * Database version: 5507 * Database creation date: Tue Mar 07 11:32:48 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 07 11:32:48 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 07 11:32:48 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11503360_USA_F2902Vi:37290201_USA_11503360_F2902Vi, (2)
In: Default
Type - Material: z_Miele_Design_GRGR
Type - Pset_BuildingElementProxyCommon - Reference: 37290201_USA_11503360_F2902Vi
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Freezers / freezers
Type - Pset_QuantityTakeOff - Reference: 37290201_USA_11503360_F2902Vi
Type - Pset_ProvisionForVoid - Width: 908 mm; Height: 2125 mm; Depth: 608 mm
Material: z_Miele_Design_GRGR, z_Miele_Design_Powder Coat_Lotus White, z_Miele_Design_Glass Black, z_Miele_Connection_Water_IN, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment

# IfcDistributionPort, Port_358006
Description: Flow; FlowDirection: SOURCEANDSINK
